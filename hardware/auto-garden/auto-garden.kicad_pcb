# Repository llsouder/auto-garden

File README.md:

# Auto-Pi-Garden

### Setup

#### Create virtual environment _(optional)_

```bash
python3 -m pip install virtualenv
```
Create virtual environment with 
```bash
python3 -m virtualenv venv
```

Activate virtual environment (before installing dependencies) with
```bash
source ./venv/bin/activate
```

Deactivate virtual environment with 
```bash
deactivate
```

#### Install WiringPi

```bash
python3 -m pip install -r requirements.txt 
```

### Run
```bash
python app.py
```

### View web interface
```
http://<host>:8000/static/index.html
```

### Not a Pi

Not a problem. remove -shunt from the RPi-Shunt directory

## KiCad design hardware/auto-garden/auto-garden.kicad_pcb

Parts:
C1, C3, C5, C6, C9, C10: 0.1u; C_Rect_L4.0mm_W2.5mm_P2.50mm
C2, C4, C7, C8, C11: 0.001u; C_Disc_D5.0mm_W2.5mm_P5.00mm
J1: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Horizontal
J2: Conn_01x06_Female; PinSocket_1x06_P2.54mm_Vertical
J3: Conn_01x03_Female; PinSocket_1x03_P2.54mm_Vertical
J4: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J5, J6: Screw_Terminal_01x02; Phoenix Contact COMBICON PTSA
JP1, JP2: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1, Q3: Q_PMOS_DGS; TO-92
Q2, Q4: Q_NMOS_DGS; TO-92
R1, R2, R3: 5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 27; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: MCP1702-3302E_TO92-3; TO-92
U2: MCP3001; DIP-8_W7.62mm

Connections:
+3V3: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, J3.2, J4.1, R1.1, U1.3, U2.1 (VREF), U2.8 (VDD)
+5V: C1.1, C2.1, J1.2, Q1.1 (D), Q3.1 (D), U1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.1, J3.3, J4.3, J5.2, J6.2, Q2.3 (S), Q4.3 (S), R2.1, R3.1, U1.1, U2.3 (IN-), U2.4 (VSS)
unnamed: J3.1, U2.2 (IN+)
unnamed: J5.1, JP1.2 (B), R4.1
unnamed: J6.1, JP2.2 (B), R5.1
unnamed: JP1.1 (A), Q1.3 (S), Q2.1 (D), R4.2
unnamed: JP2.1 (A), Q3.3 (S), Q4.1 (D), R5.2
P2_CLK: J2.2, U2.7 (CLK)
P3_data: J2.3, U2.6 (D_out)
P4_~CS: J2.4, U2.5 (~CS)
~P1: J2.1, J4.2, R1.2
~P5: J2.5, Q1.2 (G), Q2.2 (G), R2.2
~P6: J2.6, Q3.2 (G), Q4.2 (G), R3.2

Notes on the sheet:
DHT11
Moisture Sensor
Motor
External Power In
USB LED

Board: 2 copper layers, 71.1 x 55.9 mm, 30 parts (0 on the bottom side), 14 nets.

File hardware/auto-garden/auto-garden-BOM.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"REF**";"OSHW-Logo2_7.3x6mm_SilkScreen";1;"OSHW-Logo2_7.3x6mm_SilkScreen";;;
2;"REF**";"KiCad-Logo2_5mm_SilkScreen";1;"KiCad-Logo2_5mm_SilkScreen";;;
3;"J5,J6";"Phoenix Contact COMBICON PTSA";2;"Screw_Terminal_01x02";;;
4;"C1,C3,C5,C6,C9,C10";"C_Rect_L4.0mm_W2.5mm_P2.50mm";6;"0.1u";;;
5;"C2,C4,C7,C8,C11";"C_Disc_D5.0mm_W2.5mm_P5.00mm";5;"0.001u";;;
6;"J1";"PinHeader_1x02_P1.27mm_Vertical";1;"Conn_01x02_Female";;;
7;"J2";"PinHeader_1x06_P1.27mm_Vertical";1;"Conn_01x06_Female";;;
8;"J3";"PinHeader_1x03_P1.27mm_Vertical";1;"Conn_01x03_Female";;;
9;"J4";"PinHeader_1x03_P1.27mm_Vertical";1;"Conn_01x03_Male";;;
10;"JP1,JP2";"SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm";2;"Jumper_2_Open";;;
11;"Q1,Q3";"TO-92";2;"Q_PMOS_DGS";;;
12;"Q2,Q4";"TO-92";2;"Q_NMOS_DGS";;;
13;"R1,R2,R3";"R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal";3;"5k";;;
14;"R4";"R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal";1;"27";;;
15;"R5";"R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal";1;"10";;;
16;"U2";"DIP-8_W7.62mm";1;"MCP3001";;;
17;"U1";"TO-92";1;"MCP1702-3302E_TO92-3";;;

## Commit log

2019-02-04 Basic rust project with intellj stuff ignored.
2019-02-04 Blink an LED, because that is the first thing you do!
2019-02-05 Set the pin to be an output.
2019-02-06 Blinky led is working on the pi.
2019-02-07 Update On/Off message on a single line.
2019-02-10 Read light sensor on 21. If lights are off flash LED on pin 20.
2019-02-12 Use Rocket to serve a page to display live light sensor status.
2019-02-12 Clean up unused Pin var and imports.
2019-03-06 Route to turn on and off LED.
2019-03-06 Add toggle LED button to the webpage.
2019-03-06 test code to simulate lights on/off.
2019-03-06 Check light sensor more often but update only if there is a change.
2019-03-08 Record light on/off times in auto-garden.db.
2019-03-11 WIP: formatting light_sensor data.
2019-03-17 Refactor web socket code.
2019-03-17 Publishing temperature/moisture sensors readings to <hostname>:8000
2019-03-17 Adding files from Rust auto-garden.
2019-03-17 ignore idea and python files.
2019-03-21 things are working
2019-03-22 no more favicon error.
2019-03-27 Got flask socketio working.
    Add a loop that sends lights on then off every second.
2019-03-29 Moved update loop to the piconnections class.
2019-04-01 Remove unused loop and switch over to eventlet.
2019-04-01 current temp as a counter working and tested on pi.
2019-04-02 temp and humidity tested and working on the pi.
2019-04-06 Replace h1 with some style.
2019-04-07 untested led on/off and light_sensor.
2019-04-08 Move web logic out of gpio pi code.
    gpio reports temp, humidity, and light sensor status.
2019-04-08 Reading and displaying light status. Remove extra prints.
2019-04-08 Pretty up the temp and humidity display.
2019-04-08 PyCharm format.
2019-09-02 created hardware project
2019-10-26 Finished KiCAD schematic and annotation
2019-10-27 Finished schematic
2019-11-01 Finsihed board layout
2019-11-02 Made some changes to silk screen to make assembly easier
2019-11-15 Added pin descriptions to silk screen
2019-12-07 Added Gerber files
2020-12-12 added to gitignore for development
2020-12-12 renamed main.py to app.py to match flask standard
2020-12-12 updated dependencies and README
2020-12-12 fixed typo
2020-12-21 Add dumb shunt to run on windoze.
2021-02-14 add instructions to view web page.
2021-02-14 make it more obvious the light detector detects light.
2021-02-15 use the boolean value.
2021-02-15 vs code likes .venv. vs code asked so probably can use anything.
2021-02-15 editted pin header footprints
2021-02-15 rerouted with new pin headers
2021-02-16 basic sensor data model
2021-02-17 logs nulls to database periodically
2021-02-17 data is now read fromk RaspberryPi object
2021-02-17 explicitly bind arg to reader over implicitly accessing obj from global scope
2021-02-17 switched over to bootstrap via CDN for now
2021-02-22 eslint
2021-02-22 added sensor_log endpoint
2021-02-23 These names make more sense.
2021-02-24 fix typos
2021-02-24 client code requests and displays stats
2021-02-24 getting 400 error! not working!
2021-02-24 Now there is a test garden.
2021-02-24 Summarize the db update. ie show the size/number of rows.
2021-02-24 Fix ws 400 error by upgrading client socket.io
2021-03-02 added range filter params to sensor_log endpoint
2021-03-02 consume sensor_log endpoint with ranges - closes #5
2021-03-02 lower display precision
